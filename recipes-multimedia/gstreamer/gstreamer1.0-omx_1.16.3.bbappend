SRC_URI_append = " \
    file://0001-omxvideodec-Try-to-mitigate-freeze-issue-on-flushing.patch \
"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/:"
